# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MK20DN512xxx10 NXP
  pack: Keil.Kinetis_K20_DFP.1.7.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rtc_func.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MK20DN512VLL10, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .\source\MCAL\Can;.\source\MCAL\Pit;.\source\USB\USB_App;.\source\USB\common;.\source\USB\class;.\source\USB\driver;.\source\BSW\EAL\GPIO;.\source\BSW\EAL\Can;.\source\BSW\EAL\Time;.\source\BSW\EAL\USB;.\source\BSW\CDD\USB;.\source\ASW\UsbSvc;.\source\ASW\PwrCtrl;.\source\ASW\BusProxy;.\source\ASW\EcuEmu;.\source\ASW;.\startup;.\source\PROJ_CFG;.\source\MCAL;.\source;.\.cmsis\include;.\source\utilities;.\source\BSW\EAL\TEST;.\source\BSW\EAL\Can;.\source\BSW\EAL\DRV;.\source\BSW\CDD\KeySim
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  asm include: .\BSW\MCAL\inc;.\source\BSW\MCAL\src;.\source\BSW\EAL\GPIO;.\source\BSW\EAL\Can;.\source\BSW\UTIL;.\source\ASW;.\startup;.\source\PROJ_CFG;.\source\MCAL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK20DN512xxx10_flash.scf
  link misc: --remove
  group EAL
    ./source/BSW/EAL/GPIO/: EAL_GPIO.c
    ./source/BSW/EAL/Can/: EAL_CAN.c
    ./source/BSW/EAL/Time/: EAL_TIME.c
    ./source/BSW/EAL/USB/: EAL_USB.c
  group CDD
    ./source/BSW/CDD/USB/: CDD_USB.c
  group ASW
    ./source/ASW/UsbSvc/: ASW_UsbSvc.c
    ./source/ASW/PwrCtrl/: ASW_PwrCtrl.c
    ./source/ASW/BusProxy/: ASW_BusProxy.c
    ./source/ASW/EcuEmu/: ASW_EcuEmu.c
  group utilities
    ./source/utilities/: fsl_debug_console.c
  group PROJ_CFG
    ./source/PROJ_CFG/: Clock_Config.c
  group source
    ./source/: main.c
  group MCAL
    ./source/MCAL/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_cmt.c fsl_common.c fsl_crc.c fsl_dac.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_ewm.c fsl_flash.c fsl_ftm.c fsl_gpio.c fsl_i2c.c fsl_i2c_edma.c fsl_llwu.c fsl_lptmr.c fsl_pdb.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rtc.c fsl_sdhc.c fsl_sim.c fsl_smc.c fsl_sysmpu.c fsl_tsi_v2.c fsl_uart.c fsl_uart_edma.c fsl_vref.c fsl_wdog.c fsl_flexcan.c
    ./source/MCAL/Can/: MCAL_CAN.c
    ./source/MCAL/Gpio/: MCAL_GPIO.c
    ./source/MCAL/Dwt/: MCAL_DWT.c
    ./source/MCAL/Pit/: MCAL_PIT.c
  group startup
    ./startup/: startup_MK20D10.s system_MK20D10.c
  group USB
    ./source/USB/common/: usb.c usb_class.c usb_framework.c
    ./source/USB/class/: usb_bulk.c
    ./source/USB/driver/: usb_dci_kinetis.c usb_driver.c
    ./source/USB/USB_App/: usb_descriptor.c
target rtc_func Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MK20DN512xxx10 NXP
  pack: Keil.Kinetis_K20_DFP.1.7.1
  cpu: as above
  output: rtc_func.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MK20DN512VLL10, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: as above
  c include: .\source\MCAL\Can;.\source\MCAL\Pit;.\source\USB\USB_App;.\source\USB\common;.\source\USB\class;.\source\USB\driver;.\source\BSW\EAL\DRV;.\source\BSW\EAL\Time;.\source\BSW\EAL\USB;.\source\BSW\CDD\USB;.\source\ASW\UsbSvc;.\source\ASW\PwrCtrl;.\source\ASW\BusProxy;.\source\ASW\EcuEmu;.\BSW\MCAL\inc;.\source\BSW\MCAL\src;.\source\BSW\EAL\GPIO;.\source\BSW\EAL\Can;.\source\BSW\UTIL;.\source\ASW;.\startup;.\source\PROJ_CFG;.\source\MCAL\inc;.\source\utilities;.\source\BSW\EAL\TEST;.\source\.cmsis\include
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm include: .\source\BSW\EAL\DRV;.\BSW\MCAL\inc;.\source\BSW\MCAL\src;.\source\BSW\EAL\GPIO;.\source\BSW\EAL\Can;.\source\BSW\UTIL;.\source\ASW;.\startup;.\source\PROJ_CFG;.\source\MCAL\inc;.\source\utilities;.\source\BSW\EAL\TEST;.\source\.cmsis\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK20DN512xxx10_flash.scf
  link misc: --remove
